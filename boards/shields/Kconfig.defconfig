## boards/shields/Kconfig.defconfig
```kconfig
if SHIELD_TOUCHREFINER

config ZMK_KEYBOARD_NAME
    default "Touch Refiner"

endif
```
